options:
  parameters:
    generate_options: qt_gui
    id: basic_sniffer
    output_language: python
    title: Wi-SUN FSK Sniffer
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fsk_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: rx_freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: int(samp_rate / decimation / fsk_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: wisun_channel_0_frequency
  id: variable
  parameters:
    value: '863100000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1.5'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_pwr_squelch_xx_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.1'
    gate: 'True'
    ramp: '0'
    threshold: '-50'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-rx_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/gr-wisun-sniffer
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.045'
    max_dev: '0.05'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 60e3
    win: window.WIN_HAMMING
  states: {}
- name: main_tabs
  id: qtgui_tab_widget
  parameters:
    label0: RF
    label1: FSK Demodulated
    label2: Digital
    num_tabs: '3'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '0'
    freq0: wisun_channel_0_frequency-rx_offset+rx_freq_correction
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: wisun-packet
    type: byte
  states: {}
- name: qtgui_histogram_sink_x_1
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: main_tabs@1:2,0,1,1
    name: '"Symbol Histogram"'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: wisun_channel_0_frequency-rx_offset
    fftsize: '1024'
    gui_hint: main_tabs@0:0,0,1,1
    name: Input Signal
    plotconst: 'False'
    plottime: 'False'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    gui_hint: 'main_tabs@0: 1,0,1,1'
    name: '"RF Input after Low-Pass Filter"'
    plotconst: 'False'
    plottime: 'False'
    rate: '30'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: main_tabs@1:0,0,1,1
    label1: ''
    name: '"Before Symbol Sync"'
    size: '20000'
    srate: samp_rate/decimation
    tr_delay: '0.0001'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: main_tabs@1:1,0,1,1
    label1: ''
    marker1: '9'
    name: '"After Symbol Sync"'
    size: '4096'
    srate: samp_rate/decimation/samp_per_sym
    tr_delay: '0.000025'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'main_tabs@2: 0,0,1,1'
    label1: Bits
    marker1: '9'
    name: Packet Bits
    size: '2000'
    srate: samp_rate / decimation / samp_per_sym
    tr_delay: '0.0002'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: wisun-packet
    type: float
    ymax: '3'
  states: {}
- name: wisun_correlate_sync_word_bb_0
  id: wisun_correlate_sync_word_bb
  parameters:
    sfd: '0b1001000001001110'
  states: {}
- name: wisun_data_whitening_bb_0
  id: wisun_data_whitening_bb
  parameters:
    header_bits: '32'
    packet_tag: wisun-packet
  states: {}
- name: wisun_packet_data_gate_bb_0
  id: wisun_packet_data_gate_bb
  parameters:
    length_tag: wisun-packet
  states: {}
- name: wisun_pdu_add_pcapng_header_0
  id: wisun_pdu_add_pcapng_header
  parameters:
    prepend_interface_description_block: 'True'
    prepend_section_header_block: 'True'
    use_tap_dlt: 'True'
  states: {}
- name: wisun_pdu_fcs_check_0
  id: wisun_pdu_fcs_check
  parameters:
    drop_invalid_frames: 'False'
  states: {}
- name: wisun_power_squelch_relative_cc_0
  id: wisun_power_squelch_relative_cc
  parameters:
    alpha: '0.01'
    relative_threshold: '10'
  states: {}
- name: wisun_rssi_tag_cc_0
  id: wisun_rssi_tag_cc
  parameters:
    n_samples: '240'
  states: {}
- name: wisun_tag_based_dc_correction_ff_0
  id: wisun_tag_based_dc_correction_ff
  parameters:
    estimation_length: '350'
    signal_end_tag: squelch_eob
    signal_start_tag: squelch_sob
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_pwr_squelch_xx_1, '0', qtgui_histogram_sink_x_1, '0']
- [analog_quadrature_demod_cf_0, '0', wisun_tag_based_dc_correction_ff_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_tag_debug_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [digital_binary_slicer_fb_0, '0', wisun_correlate_sync_word_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', analog_pwr_squelch_xx_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_0, '0', wisun_power_squelch_relative_cc_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_1, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, wisun_pdu_fcs_check_0, pdus]
- [wisun_correlate_sync_word_bb_0, '0', blocks_char_to_float_0, '0']
- [wisun_correlate_sync_word_bb_0, '0', wisun_packet_data_gate_bb_0, '0']
- [wisun_data_whitening_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [wisun_packet_data_gate_bb_0, '0', wisun_data_whitening_bb_0, '0']
- [wisun_pdu_add_pcapng_header_0, pdus, blocks_message_debug_1_0, print]
- [wisun_pdu_fcs_check_0, pdus, wisun_pdu_add_pcapng_header_0, pdus]
- [wisun_pdu_add_pcapng_header_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]
- [wisun_power_squelch_relative_cc_0, '0', wisun_rssi_tag_cc_0, '0']
- [wisun_rssi_tag_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [wisun_tag_based_dc_correction_ff_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
