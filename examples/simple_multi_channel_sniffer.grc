options:
  parameters:
    generate_options: qt_gui
    id: simple_multi_channel_sniffer
    output_language: python
    title: Multi-Channel Wi-SUN FSK Sniffer
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: '864100000'
  states: {}
- name: channel_spacing
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: rx_freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: wisun_channel_0_frequency
  id: variable
  parameters:
    value: '863100000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/gr-wisun-sniffer
    type: byte
    unbuffered: 'True'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '0'
    freq0: center_frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_frequency
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: wisun_multi_channel_receiver_0
  id: wisun_multi_channel_receiver
  parameters:
    center_frequency: center_frequency
    channel_0_frequency: wisun_channel_0_frequency
    channel_spacing: channel_spacing
    channels: '[0,1,2,3,4,5,6,7,8,9,10]'
    sample_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', wisun_multi_channel_receiver_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [wisun_multi_channel_receiver_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
