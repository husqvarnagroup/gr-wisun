options:
  parameters:
    generate_options: no_gui
    id: simple_sniffer
    output_language: python
    title: Wi-SUN FSK Sniffer
  states: {}

blocks:
- name: channel_spacing
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fsk_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: rx_freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: int(samp_rate / decimation / fsk_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: wisun_channel_0_frequency
  id: variable
  parameters:
    value: '863100000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/gr-wisun-sniffer
    type: byte
    unbuffered: 'True'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '0'
    freq0: wisun_channel_0_frequency-rx_offset+rx_freq_correction
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: wisun_pdu_add_pcapng_header_0
  id: wisun_pdu_add_pcapng_header
  parameters:
    prepend_interface_description_block: 'True'
    prepend_section_header_block: 'True'
    use_tap_dlt: 'True'
  states: {}
- name: wisun_single_channel_receiver_0
  id: wisun_single_channel_receiver
  parameters:
    channel_spacing: channel_spacing
    decimation: decimation
    fec: 'False'
    frequency_offset: rx_offset
    gated_power_squelch: 'False'
    sample_rate: samp_rate
    samples_per_symbol: samp_per_sym
  states: {}

connections:
- [osmosdr_source_0, '0', wisun_single_channel_receiver_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [wisun_pdu_add_pcapng_header_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]
- [wisun_single_channel_receiver_0, pdus, wisun_pdu_add_pcapng_header_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
