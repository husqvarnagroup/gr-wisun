options:
  parameters:
    generate_options: no_gui
    id: simple_sniffer
    output_language: python
    title: Wi-SUN FSK Sniffer
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fsk_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: rx_freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: int(samp_rate / decimation / fsk_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: wisun_channel_0_frequency
  id: variable
  parameters:
    value: '863100000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-rx_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/gr-wisun-sniffer
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '0'
    freq0: wisun_channel_0_frequency-rx_offset+rx_freq_correction
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: wisun_baseband_channel_receiver_1
  id: wisun_baseband_channel_receiver
  parameters:
    samples_per_symbol: samp_per_sym
    sfd: '36942'
  states: {}
- name: wisun_pdu_add_pcapng_header_0
  id: wisun_pdu_add_pcapng_header
  parameters:
    prepend_interface_description_block: 'True'
    prepend_section_header_block: 'True'
    use_tap_dlt: 'True'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', wisun_baseband_channel_receiver_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [wisun_baseband_channel_receiver_1, pdus, wisun_pdu_add_pcapng_header_0, pdus]
- [wisun_pdu_add_pcapng_header_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
